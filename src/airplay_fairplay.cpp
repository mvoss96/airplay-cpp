// FairPlay setup replies. The four fixed replies of the first step and the header of the second come from
// shairport-sync (rtsp.c, MIT license, copyright James Laird 2013 and Mike Brady 2014-2026); see NOTICE.

#include "airplay_fairplay.h"

#include "airplay_crypto.h"
#include "airplay_util.h"

#include <cstring>

namespace airplay {

/// "FPLY", version (overwritten with the sender's 2 or 3), type 1 (setup), sequence 2, length (130), then the mode
static const uint8_t REPLY_PREFIX[13] = {
    0x46, 0x50, 0x4c, 0x59, 0x03, 0x01, 0x02, 0x00, 0x00, 0x00, 0x00, 0x82, 0x02,
};
/// The rest of the first reply, one per mode
static const uint8_t REPLY_BODIES[4][128] = {
    {
        0x0f, 0x9f, 0x3f, 0x9e, 0x0a, 0x25, 0x21, 0xdb, 0xdf, 0x31, 0x2a, 0xb2, 0xbf, 0xb2, 0x9e, 0x8d,
        0x23, 0x2b, 0x63, 0x76, 0xa8, 0xc8, 0x18, 0x70, 0x1d, 0x22, 0xae, 0x93, 0xd8, 0x27, 0x37, 0xfe,
        0xaf, 0x9d, 0xb4, 0xfd, 0xf4, 0x1c, 0x2d, 0xba, 0x9d, 0x1f, 0x49, 0xca, 0xaa, 0xbf, 0x65, 0x91,
        0xac, 0x1f, 0x7b, 0xc6, 0xf7, 0xe0, 0x66, 0x3d, 0x21, 0xaf, 0xe0, 0x15, 0x65, 0x95, 0x3e, 0xab,
        0x81, 0xf4, 0x18, 0xce, 0xed, 0x09, 0x5a, 0xdb, 0x7c, 0x3d, 0x0e, 0x25, 0x49, 0x09, 0xa7, 0x98,
        0x31, 0xd4, 0x9c, 0x39, 0x82, 0x97, 0x34, 0x34, 0xfa, 0xcb, 0x42, 0xc6, 0x3a, 0x1c, 0xd9, 0x11,
        0xa6, 0xfe, 0x94, 0x1a, 0x8a, 0x6d, 0x4a, 0x74, 0x3b, 0x46, 0xc3, 0xa7, 0x64, 0x9e, 0x44, 0xc7,
        0x89, 0x55, 0xe4, 0x9d, 0x81, 0x55, 0x00, 0x95, 0x49, 0xc4, 0xe2, 0xf7, 0xa3, 0xf6, 0xd5, 0xba,
    },
    {
        0xcf, 0x32, 0xa2, 0x57, 0x14, 0xb2, 0x52, 0x4f, 0x8a, 0xa0, 0xad, 0x7a, 0xf1, 0x64, 0xe3, 0x7b,
        0xcf, 0x44, 0x24, 0xe2, 0x00, 0x04, 0x7e, 0xfc, 0x0a, 0xd6, 0x7a, 0xfc, 0xd9, 0x5d, 0xed, 0x1c,
        0x27, 0x30, 0xbb, 0x59, 0x1b, 0x96, 0x2e, 0xd6, 0x3a, 0x9c, 0x4d, 0xed, 0x88, 0xba, 0x8f, 0xc7,
        0x8d, 0xe6, 0x4d, 0x91, 0xcc, 0xfd, 0x5c, 0x7b, 0x56, 0xda, 0x88, 0xe3, 0x1f, 0x5c, 0xce, 0xaf,
        0xc7, 0x43, 0x19, 0x95, 0xa0, 0x16, 0x65, 0xa5, 0x4e, 0x19, 0x39, 0xd2, 0x5b, 0x94, 0xdb, 0x64,
        0xb9, 0xe4, 0x5d, 0x8d, 0x06, 0x3e, 0x1e, 0x6a, 0xf0, 0x7e, 0x96, 0x56, 0x16, 0x2b, 0x0e, 0xfa,
        0x40, 0x42, 0x75, 0xea, 0x5a, 0x44, 0xd9, 0x59, 0x1c, 0x72, 0x56, 0xb9, 0xfb, 0xe6, 0x51, 0x38,
        0x98, 0xb8, 0x02, 0x27, 0x72, 0x19, 0x88, 0x57, 0x16, 0x50, 0x94, 0x2a, 0xd9, 0x46, 0x68, 0x8a,
    },
    {
        0xc1, 0x69, 0xa3, 0x52, 0xee, 0xed, 0x35, 0xb1, 0x8c, 0xdd, 0x9c, 0x58, 0xd6, 0x4f, 0x16, 0xc1,
        0x51, 0x9a, 0x89, 0xeb, 0x53, 0x17, 0xbd, 0x0d, 0x43, 0x36, 0xcd, 0x68, 0xf6, 0x38, 0xff, 0x9d,
        0x01, 0x6a, 0x5b, 0x52, 0xb7, 0xfa, 0x92, 0x16, 0xb2, 0xb6, 0x54, 0x82, 0xc7, 0x84, 0x44, 0x11,
        0x81, 0x21, 0xa2, 0xc7, 0xfe, 0xd8, 0x3d, 0xb7, 0x11, 0x9e, 0x91, 0x82, 0xaa, 0xd7, 0xd1, 0x8c,
        0x70, 0x63, 0xe2, 0xa4, 0x57, 0x55, 0x59, 0x10, 0xaf, 0x9e, 0x0e, 0xfc, 0x76, 0x34, 0x7d, 0x16,
        0x40, 0x43, 0x80, 0x7f, 0x58, 0x1e, 0xe4, 0xfb, 0xe4, 0x2c, 0xa9, 0xde, 0xdc, 0x1b, 0x5e, 0xb2,
        0xa3, 0xaa, 0x3d, 0x2e, 0xcd, 0x59, 0xe7, 0xee, 0xe7, 0x0b, 0x36, 0x29, 0xf2, 0x2a, 0xfd, 0x16,
        0x1d, 0x87, 0x73, 0x53, 0xdd, 0xb9, 0x9a, 0xdc, 0x8e, 0x07, 0x00, 0x6e, 0x56, 0xf8, 0x50, 0xce,
    },
    {
        0x90, 0x01, 0xe1, 0x72, 0x7e, 0x0f, 0x57, 0xf9, 0xf5, 0x88, 0x0d, 0xb1, 0x04, 0xa6, 0x25, 0x7a,
        0x23, 0xf5, 0xcf, 0xff, 0x1a, 0xbb, 0xe1, 0xe9, 0x30, 0x45, 0x25, 0x1a, 0xfb, 0x97, 0xeb, 0x9f,
        0xc0, 0x01, 0x1e, 0xbe, 0x0f, 0x3a, 0x81, 0xdf, 0x5b, 0x69, 0x1d, 0x76, 0xac, 0xb2, 0xf7, 0xa5,
        0xc7, 0x08, 0xe3, 0xd3, 0x28, 0xf5, 0x6b, 0xb3, 0x9d, 0xbd, 0xe5, 0xf2, 0x9c, 0x8a, 0x17, 0xf4,
        0x81, 0x48, 0x7e, 0x3a, 0xe8, 0x63, 0xc6, 0x78, 0x32, 0x54, 0x22, 0xe6, 0xf7, 0x8e, 0x16, 0x6d,
        0x18, 0xaa, 0x7f, 0xd6, 0x36, 0x25, 0x8b, 0xce, 0x28, 0x72, 0x6f, 0x66, 0x1f, 0x73, 0x88, 0x93,
        0xce, 0x44, 0x31, 0x1e, 0x4b, 0xe6, 0xc0, 0x53, 0x51, 0x93, 0xe5, 0xef, 0x72, 0xe8, 0x68, 0x62,
        0x33, 0x72, 0x9c, 0x22, 0x7d, 0x82, 0x0c, 0x99, 0x94, 0x45, 0xd8, 0x92, 0x46, 0xc8, 0xc3, 0x59,
    },
};
/// Header of the second reply (version byte overwritten with the sender's), which ends with the message's last 20 bytes
static const uint8_t SECOND_REPLY_HEADER[12] = {
    0x46, 0x50, 0x4c, 0x59, 0x03, 0x01, 0x04, 0x00, 0x00, 0x00, 0x00, 0x14,
};

static constexpr size_t VERSION_POSITION = 4;
static constexpr size_t TYPE_POSITION = 5;
static constexpr size_t SEQUENCE_POSITION = 6;
static constexpr size_t MODE_POSITION = 14;
static constexpr size_t SECOND_REPLY_SUFFIX = 20;

size_t fairplay_setup_reply(const uint8_t *message, size_t length, uint8_t *reply, size_t size) {
  if (message == nullptr || length < FAIRPLAY_SETUP_FIRST_SIZE || std::memcmp(message, "FPLY", 4) != 0 ||
      (message[VERSION_POSITION] != 2 && message[VERSION_POSITION] != 3) || message[TYPE_POSITION] != 1 ||
      size < FAIRPLAY_SETUP_REPLY_SIZE) {
    return 0;
  }
  // AirPlay 2 senders use FairPlay version 3, iTunes for Windows (AirPlay 1 / RAOP) version 2. The known-answer
  // reply bodies are the same for both; only the version byte in the reply header is echoed back from the message.
  const uint8_t version = message[VERSION_POSITION];
  if (message[SEQUENCE_POSITION] == 1 && length == FAIRPLAY_SETUP_FIRST_SIZE) {
    const uint8_t mode = message[MODE_POSITION];
    if (mode >= 4)
      return 0;
    std::memcpy(reply, REPLY_PREFIX, sizeof(REPLY_PREFIX));
    reply[VERSION_POSITION] = version;
    reply[sizeof(REPLY_PREFIX)] = mode;
    std::memcpy(reply + sizeof(REPLY_PREFIX) + 1, REPLY_BODIES[mode], sizeof(REPLY_BODIES[mode]));
    return FAIRPLAY_SETUP_REPLY_SIZE;
  }
  if (message[SEQUENCE_POSITION] == 3 && length == FAIRPLAY_SETUP_P3_SIZE) {
    std::memcpy(reply, SECOND_REPLY_HEADER, sizeof(SECOND_REPLY_HEADER));
    reply[VERSION_POSITION] = version;
    std::memcpy(reply + sizeof(SECOND_REPLY_HEADER), message + length - SECOND_REPLY_SUFFIX, SECOND_REPLY_SUFFIX);
    return sizeof(SECOND_REPLY_HEADER) + SECOND_REPLY_SUFFIX;
  }
  return 0;
}

// iTunes for Windows wraps the audio key in a 72-byte blob: HEADER, A (16 bytes), LENGTH, an HMAC-SHA1 tag
// (20 bytes) and the encrypted key (16 bytes). Its keys come from the two FairPlay setup messages.
bool Crypto::decrypt_fairplay_key(const uint8_t *p2, const uint8_t *p3, const uint8_t *blob, uint8_t *key) {
  static const uint8_t HEADER[16] = {0x46, 0x50, 0x4c, 0x59, 0x01, 0x02, 0x01, 0x00,
                                     0x00, 0x00, 0x00, 0x3c, 0x00, 0x00, 0x00, 0x00};
  static const uint8_t LENGTH[4] = {0x00, 0x00, 0x00, 0x10};
  if (std::memcmp(blob, HEADER, sizeof(HEADER)) != 0 || std::memcmp(blob + 32, LENGTH, sizeof(LENGTH)) != 0)
    return false;

  // 128 bytes of each setup message (the reply's after its header, the second message's), each decrypted with
  // AES-128-CBC under a fixed key and IV of the mode the sender chose (the reply's byte 13); then salt || second ||
  // reply || salt is hashed into the keys
  static const uint8_t KEYS[4][16] = {
      {0xb5, 0xf1, 0x26, 0xdd, 0x6e, 0x3e, 0x05, 0xa4, 0x1a, 0x96, 0x33, 0x61, 0x15, 0x3e, 0xe5, 0xdc},
      {0xeb, 0xa1, 0xf1, 0x18, 0xef, 0x08, 0xb7, 0x1c, 0x60, 0xd5, 0x0f, 0xf0, 0xa9, 0x8c, 0x94, 0xb4},
      {0x29, 0x7b, 0x84, 0x83, 0x41, 0x7c, 0xc9, 0xd5, 0x1b, 0x82, 0xd1, 0x7b, 0xba, 0xa7, 0x61, 0x9d},
      {0x21, 0x41, 0x78, 0x3a, 0xac, 0x0b, 0x0b, 0x27, 0x19, 0x56, 0xcd, 0x1d, 0xbd, 0x01, 0x95, 0xc2},
  };
  static const uint8_t IVS[4][16] = {
      {0xe7, 0xc3, 0x45, 0xf5, 0x00, 0x13, 0xe4, 0x93, 0x1e, 0x0a, 0x33, 0xe2, 0x39, 0xe8, 0xb3, 0xdb},
      {0x3e, 0x08, 0x3f, 0x58, 0x4f, 0xf9, 0x88, 0x3e, 0x49, 0x2c, 0xf3, 0x65, 0x49, 0x02, 0x78, 0xe2},
      {0xa7, 0xed, 0x28, 0xe5, 0x6a, 0x2f, 0x8a, 0x6f, 0x7e, 0x46, 0xfa, 0x76, 0x5a, 0x6c, 0x04, 0x0a},
      {0x69, 0x8a, 0x2b, 0x3c, 0xf2, 0x6a, 0xa8, 0x29, 0xb1, 0x75, 0xba, 0x84, 0x2c, 0xec, 0x84, 0x21},
  };
  const uint8_t mode = p2[13];
  if (mode >= 4)
    return false;
  uint8_t message[16 + 256 + 16];
  if (!this->aes128_cbc_decrypt(KEYS[mode], IVS[mode], p3 + 16, message + 16, 128) ||
      !this->aes128_cbc_decrypt(KEYS[mode], IVS[mode], p2 + 14, message + 16 + 128, 128))
    return false;

  // Kaes = MD5(salt || D || salt), Kmac = SHA-1(salt || D || salt), each with its own fixed salts
  uint8_t kaes[16];
  uint8_t kmac[20];
  std::memcpy(message, "#l*GY&cqnwo*&5sd", 16);
  std::memcpy(message + 16 + 256, "57bv&%niulqpdg3z", 16);
  md5(message, sizeof(message), kaes);  // The library's own: MD5 may be left out of mbedTLS
  std::memcpy(message, "asdiuAD8AKA9a>/?", 16);
  std::memcpy(message + 16 + 256, "!D4H&2*203kjgha9", 16);
  if (!this->sha1(message, sizeof(message), kmac))
    return false;

  // The key is AES-128-ECB(Kaes) decrypted, xor A, and must carry the tag HMAC-SHA1(Kmac, HEADER || A || LENGTH ||
  // key)
  uint8_t mac_message[36 + AES_KEY_SIZE];
  if (!this->aes128_ecb_decrypt(kaes, blob + 56, mac_message + 36, AES_KEY_SIZE))
    return false;
  for (size_t i = 0; i < AES_KEY_SIZE; i++)
    mac_message[36 + i] ^= blob[16 + i];
  std::memcpy(mac_message, blob, 36);
  uint8_t tag[20];
  if (!this->hmac_sha1(kmac, sizeof(kmac), mac_message, sizeof(mac_message), tag))
    return false;
  uint8_t differ = 0;
  for (size_t i = 0; i < sizeof(tag); i++)
    differ |= tag[i] ^ blob[36 + i];
  if (differ != 0)
    return false;
  std::memcpy(key, mac_message + 36, AES_KEY_SIZE);
  return true;
}

}  // namespace airplay
